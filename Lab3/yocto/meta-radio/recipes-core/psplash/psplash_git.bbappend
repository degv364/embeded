FILESEXTRAPATHS_prepend_poky := "${THISDIR}/files:"

SPLASH_IMAGES = "file://lamborghini_logo-img.h;outsuffix=default"
